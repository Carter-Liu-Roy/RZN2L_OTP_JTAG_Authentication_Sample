<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\OTP_N2L_ID_JTAG_example.ewp</path>
    </project>
    <batchBuild/>
</workspace>
